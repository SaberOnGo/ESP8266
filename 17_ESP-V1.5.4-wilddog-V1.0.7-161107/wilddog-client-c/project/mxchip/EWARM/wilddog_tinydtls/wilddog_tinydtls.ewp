# IAR project wilddog_tinydtls.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205RG ST STM32F205RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; WILDDOG_PORT_TYPE_MXCHIP; WILDDOG_PORT=5684
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\..\Demos\COM.MXCHIP.BASIC; ..\..\..\..\..\include; ..\..\..\..\..\MICO; ..\..\..\..\..\Support; ..\..\..\..\..\Board\MiCOKit-3162; ..\..\..\..\..\Platform\include; ..\..\..\..\..\Platform\Cortex-M3; ..\..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\..\Platform; ..\..\..\..\..\Platform\MCU; ..\..\..\..\..\libraries\utilities; ..\..\..\..\..\libraries\utilities\json_c; ..\..\..\..\..\libraries; ..\..\..\..\..\MICO\core; ..\..\..\..\..\MICO\security; ..\..\..\..\..\MICO\system\command_console; ..\..\..\..\..\MICO\system; ..\..\..\..\..\include\MicoDrivers; ..\..\..\..\include; ..\..\..\..\src; ..\..\..\..\src\networking\coap; ..\..\..\..\platform\mxchip
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: wilddog_tinydtls.bin
  ILINK.IlinkOutputFile: wilddog_tinydtls.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\Board\MiCOKit-3162\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group Application
    ../../../../examples/mxchip/: demo.c mico_config.h
  group Board/MiCOKit-3162
    ../../../../../Board/MiCOKit-3162/: platform.c platform.h platform_config.h
  group include
    ../../../../../include/: MICO.h MicoAES.h MicoSRPServer.h
  group include/MicoDriver
    ../../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group libraries/utilities
    ../../../../../libraries/utilities/: AESUtils.c CheckSumUtils.c HTTPUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group libraries/utilities/json_c
    ../../../../../libraries/utilities/json_c/: arraylist.c arraylist.h bits.h config.h debug.c debug.h json.h json_inttypes.h json_object.c json_object.h json_object_private.h json_tokener.c json_tokener.h json_util.c json_util.h linkhash.c linkhash.h printbuf.c printbuf.h
  group libwilddog/include
    ../../../../include/: wilddog.h wilddog_api.h wilddog_config.h wilddog_debug.h wilddog_port.h
  group libwilddog/platform
    ../../../../platform/mxchip/: wilddog_mxchip.c wilddog_mxchip.h
  group libwilddog/src
    ../../../../src/: performtest.c ramtest.c test_lib.h utlist.h wilddog_api.c wilddog_common.c wilddog_common.h wilddog_conn.c wilddog_conn.h wilddog_conn_manage.c wilddog_ct.c wilddog_ct.h wilddog_debug.c wilddog_endian.h wilddog_event.c wilddog_event.h wilddog_node.c wilddog_payload.h wilddog_sec.h wilddog_sec_host.c wilddog_sec_host.h wilddog_store.c wilddog_store.h wilddog_url_parser.c wilddog_url_parser.h
  group libwilddog/src/networking/coap
    ../../../../src/networking/coap/: bits.h option.c option.h pdu.c pdu.h wilddog_conn_coap.c wilddog_conn_coap.h
  group libwilddog/src/secure/tinydtls
    ../../../../src/secure/tinydtls/: alert.h ccm.h crypto.c crypto.h debug.h dtls.c dtls.h dtls_config.h dtls_time.c dtls_time.h ecc.c ecc.h global.h hmac.c hmac.h netq.c netq.h numeric.h peer.c peer.h prng.h rijndael.c rijndael.h session.c session.h sha2.c sha2.h state.h t_list.h tiny_ccm.c tiny_debug.c tiny_platform.h tinydtls.h uthash.h utlist.h wilddog_conn_sec_dtls.c
  group libwilddog/src/serialize/cbor
    ../../../../src/serialize/cbor/: wilddog_cbor.c wilddog_cbor.h
  group mico/core
    ../../../../../MICO/core/: mico_config.c mxchipWNet_cm3_sdio.a
    ../../../../../MICO/core/RF driver/: wlan_firmware.c
  group mico/security
    ../../../../../MICO/security/: MicoCrypto.a
  group mico/system
    ../../../../../MICO/system/config_server/: config_server.c config_server_menu.c
    ../../../../../MICO/system/easylink/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a system_easylink.c system_easylink_delegate.c system_easylink_wac.c
    ../../../../../MICO/system/command_console/: mico_cli.c
    ../../../../../MICO/system/mdns/: mico_mdns.c
    ../../../../../MICO/system/: mico_system_init.c mico_system_monitor.c mico_system_notification.c mico_system_para_storage.c mico_system_power_daemon.c system.h system_factory_test.c system_misc.c
    ../../../../../MICO/system/tftp_ota/: tftp.h tftp_ota.c tftpc.o
  group Platform/Cortex-M3
    ../../../../../Platform/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MFiAuth
    ../../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI Flash
    ../../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../../Platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/EWARM
    ../../../../../Platform/MCU/STM32F2xx/EWARM/: startup_stm32f2xx_EWARM.s
  group Platform/MCU/STM32F2xx/Peripherals
    ../../../../../Platform/MCU/STM32F2xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_HAL_Driver
    ../../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_StdPeriph_Driver
    ../../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Platform/MCU/STM32F2xx/wlan_bus_driver
    ../../../../../Platform/MCU/STM32F2xx/wlan_bus_driver/: wlan_bus_sdio.c wlan_platform.c
